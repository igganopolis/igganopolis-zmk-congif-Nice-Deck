## zmk-config-Nice=Deck/config/boards/shields/Nice=Deck/Kconfig.defconfig
```kconfig
if SHEILD_NICE=DECK
            
config ZMK_KEYBOARD_NAME
    default "Nice=Deck"

endif
```
